# Keil uVision project DTQ_RP551CPU_WHTY0109.uvprojx, settings and files
target DTQ_RP551CPU_WHTY0109 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DTQ_RP551CPU_WHTY0109_V0300.hex +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: BRANCH_WHTY,ZL_RP551_MAIN_H
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\include;..\User;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CmsisCore
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Stdlib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Include
    ../include/: m24sr_cmd.h main.h stm32f10x_conf.h stm32f10x_it.h eeprom.h ringbuffer.h gpio.h whitelist.h zl_rp551_main_e.h zl_rp551_main_f.h zl_rp551_main_h.h
  group Bsp
    ../Bsp/: m24sr_cmd.c mfrc500.c eeprom.c gpio.c mfrc500_hw.c mfrc500_ios14443.c mfrc500.h mfrc500_config.h
  group User
    ../User/: main.c app_serial_cmd_process.c app_send_data_process.c app_show_message_process.c app_systick_package_process.c app_spi_send_data_process.c app_card_process.c app_timer.c stm32f10x_it.c ringbuffer.c whitelist.c board.c
